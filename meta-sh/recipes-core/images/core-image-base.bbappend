IMAGE_INSTALL:append = " shooresh-image"
